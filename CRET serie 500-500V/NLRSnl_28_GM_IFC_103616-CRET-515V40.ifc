Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-06T08:18:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 06 08:18:27 2023 * Host: MAV-DTP-TESSA * Database: C:\Users\T6FAF~1.PLA\AppData\Local\Temp\fdaae377-05c3-4360-8a65-4f585b0c56b6\11218fcb-68d6-433a-a8ab-05699cb5dd51\ifc * Database version: 5507 * Database creation date: Thu Apr 06 08:18:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 06 08:18:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 06 08:18:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 103613, NLRSnl_28_GM_103-CRET-Serie-500_R20:103613_CRET-515 V40:344585
In: Level 0
Type - Description: CRET-515 V40; Material: Corrossiebestendigheidsklasse 3, corrosion resistance class 3, Mavotrans - stainless steel
Type - Constraints - Default Elevation: 200 mm
Type - Construction - c: 20 mm; d: 12 mm; h_w: 60 mm; l_w: 80 mm; p_l: 110 mm; x1: 0 mm; x2: 0 mm; x3: 104 mm
Type - Dimensions - Dowel bar height: 25 mm; Dowel bar width: 15 mm; Dowel length: 410 mm; Sleeve length: 162 mm
Type - Identity Data - Artikelnummer | Article number: 103613; Beschrijving | Description: CRET-515 V40; Laatste versie | Last version: 31-03-2023; Lateral displacement +/-: 20 mm; Leverancier | Supplier: Mavotrans; NL-SfB code: 28; OmniClass Number: 23.25.10.27.11; OmniClass Title: Reinforcement Components; Opmerkingen | Comments: Dwarskrachtdeuvel met zijdelingse verplaatsing | Shear load connector with lateral displacement; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 103613_CRET-515 V40; URL: https://mavotrans.nl/cret-500v-serie.html; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Dowel_material: Corrossiebestendigheidsklasse 3, corrosion resistance class 3; Material: Corrossiebestendigheidsklasse 3, corrosion resistance class 3
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_103-CRET-Serie-500_R20
Type - Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_103-CRET-Serie-500_R20:103613_CRET-515 V40
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NLRSnl_28_GM_103-CRET-Serie-500_R20:103613_CRET-515 V40
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level: Level 0; Schedule Level: Level: Level 0
Dimensions - Area: 0.592936 m2; e_accepted: 130 mm; e Fuge / joint / guinto: 130 mm; Volume: 0.00023299 m3
Graphics - warning: no
Other - Family: NLRSnl_28_GM_103-CRET-Serie-500_R20: 103613_CRET-515 V40; Family and Type: NLRSnl_28_GM_103-CRET-Serie-500_R20: 103613_CRET-515 V40; Type: NLRSnl_28_GM_103-CRET-Serie-500_R20: 103613_CRET-515 V40; Type Id: NLRSnl_28_GM_103-CRET-Serie-500_R20: 103613_CRET-515 V40
Phasing - Phase Created: New Construction
